Commit message: added imu

File: urdf/rur.urdf (robot description, URDF)
Before this commit: robot rur, 5 links, 4 joints
Links:
- link base_link: geometry visual mesh filename=package://nct_robot/meshes/robot.stl scale=0.001 0.001 0.001
